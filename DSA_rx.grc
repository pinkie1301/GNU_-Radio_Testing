options:
  parameters:
    author: pinkie
    generate_options: qt_gui
    id: DSA_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: channel_bw
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label: freq
    label0: 0Hz
    label1: 910MHz
    label2: 2.4GHz
    num_opts: '3'
    option0: '0'
    option1: 910e6
    option2: 2.4e9
    type: real
    value: '0'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_crc(len_key, num_key)
  states: {}
- name: len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: num_key
  id: variable
  parameters:
    value: '"packet_num"'
  states: {}
- name: rfgain
  id: variable_qtgui_range
  parameters:
    label: RF
    start: '0'
    step: '1'
    stop: '100'
    value: '28'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: .\output_video.ts
    type: byte
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: '32'
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"packet_len"'
    output_symbols: 'False'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '"burst"'
    trigger_tag_key: '"packet_len"'
    type: byte
  states: {}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: hdr_format
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    gain0: rfgain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: v1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: v1
  states: {}

connections:
- [blocks_repack_bits_bb_1, '0', digital_crc32_bb_0, '0']
- [digital_crc32_bb_0, '0', blocks_file_sink_0, '0']
- [digital_crc32_bb_0, '0', qtgui_sink_x_1, '0']
- [digital_gmsk_demod_0, '0', virtual_sink_0, '0']
- [digital_header_payload_demux_0, '0', digital_protocol_parser_b_0, '0']
- [digital_header_payload_demux_0, '1', blocks_repack_bits_bb_1, '0']
- [digital_protocol_parser_b_0, info, digital_header_payload_demux_0, header_data]
- [uhd_usrp_source_0, '0', digital_gmsk_demod_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [virtual_source_0, '0', digital_header_payload_demux_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
