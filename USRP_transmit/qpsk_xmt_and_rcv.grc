options:
  parameters:
    author: pinkie
    generate_options: qt_gui
    id: qpsk_xmt_and_rcv
    output_language: python
    title: QPSK mod
  states: {}

blocks:
- name: Input_File_Path
  id: variable
  parameters:
    value: '"./inputs/input_img.png"'
  states: {}
- name: MTU
  id: variable
  parameters:
    value: '1500'
  states: {}
- name: NS
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: Output_File_Path
  id: variable
  parameters:
    value: '"./outputs/output_qpsk.png"'
  states: {}
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: b210_ID_0
  id: variable
  parameters:
    value: '"serial=327543A"'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '20000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.08'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[1+1j, -1+1j, -1-1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.040'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 128e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 256e3
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    comment: |-
      CMA algo. for QPSK
      default .0001 is too big
      using =<.00002 instead
    cons: qpsk
    modulus: '4'
    step_size: '.000001'
    type: cma
  states: {}
- name: x310_ID
  id: variable
  parameters:
    value: '"serial=30969D2"'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: NS
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: Output_File_Path
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      0,1,2,3  映射到  0,1
      給 correlation code
    endianness: gr.GR_MSB_FIRST
    k: '2'
    l: '1'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '256'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '52'
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    display: 'False'
    filter: '"packet_len"'
    name: rx_access_code_debug
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: ''
    type: byte
    vector: '[37,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,93]'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '4'
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: |-
      同時校正後續 constellation 頻率偏移和相位偏移
      Order:
      2 -> BPSK
      4 -> QPSK
      8 -> 8PSK
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      Modules:
      2 -> BPSK
      4 -> QPSK
      8 -> 8PSK
    modulus: '4'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    comment: 校正訊號偏移
    filter_size: '44'
    rolloff: excess_bw
    samps_per_sym: sps
    type: cc
    w: phase_bw
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    FileName: Input_File_Path
    Pkt_len: '1024'
    _source_code: "\"\"\"\nEmbedded Python Block: File Source to Tagged Stream\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pmt\nimport os.path\nimport sys\nimport base64\n\n\"\"\"\nState definitions\n    0   idle\n    1   send preamble\n    2   send file data\n    3   send file name\n    4   send post filler\n\"\"\"\n\nclass blk(gr.sync_block):\n    def __init__(self, FileName='None', Pkt_len=52):\n        gr.sync_block.__init__(\n            self,\n            name='EPB: File Source to Tagged Stream',\n            in_sig=None,\n            out_sig=[np.uint8])\n        \n        \n        self.FileName = FileName\n        self.Pkt_len = Pkt_len\n        self.state = 0      # idle state\n        self.pre_count = 0\n        self.indx = 0\n        self._debug = 0     # debug\n        self.data = \"\"\n\n        if (os.path.exists(self.FileName)):\n            # open input file\n            self.f_in = open (self.FileName, 'rb')\n            self._eof = False\n            if (self._debug):\n                print (\"[EPB encode] File name:\", self.FileName)\n            self.state = 1\n        else:\n            print('[EPB encode] ', self.FileName, 'does not exist')\n            self._eof = True\n            self.state = 0\n\n        self.char_list = [37,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,93]\n        self.c_len = len (self.char_list)\n        print (\"[EPB encode] c_len: \", self.c_len)\n        self.filler = [37,85,85,85, 35,69,79,70, 85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,93]\n        self.f_len = len (self.filler)\n\n    def forecast(self, noutput_items, ninput_items_required):\n        # 告訴 scheduler 我們需要至少 512 bytes 的輸出空間\n        noutput_items = max(2048, noutput_items)\n        \n    def work(self, input_items, output_items):\n\n        if (self.state == 0):\n            # idle\n            return (0)\n\n        elif (self.state == 1):\n            # send preamble\n            if (self._debug):\n                print (\"[EPB encode] state = 1\", self.pre_count)\n            key1 = pmt.intern(\"packet_len\")\n            val1 = pmt.from_long(self.c_len)\n            self.add_item_tag(0, # Write to output port 0\n                self.indx,   # Index of the tag\n                key1,   # Key of the tag\n                val1    # Value of the tag\n                )\n            self.indx += self.c_len\n            i = 0\n            while (i < self.c_len):\n                output_items[0][i] = self.char_list[i]\n                i += 1\n            self.pre_count += 1\n            if (self.pre_count > 64):\n                self.pre_count = 0\n                self.state = 2      # send msg\n            return (self.c_len)\n\n        elif (self.state == 2):\n            while (not (self._eof)):\n                buff = self.f_in.read (self.Pkt_len)\n                b_len = len(buff)\n                if b_len == 0:\n                    print ('[EPB encode] End of file')\n                    self._eof = True\n                    self.f_in.close()\n                    self.state = 3      # send file name\n                    self.pre_count = 0\n                    break\n                # convert to Base64\n                encoded = base64.b64encode (buff)\n                e_len = len(encoded)\n                if (self._debug):\n                    print ('[EPB encode] b64 length =', e_len)\n                key0 = pmt.intern(\"packet_len\")\n                val0 = pmt.from_long(e_len)\n                self.add_item_tag(0, # Write to output port 0\n                    self.indx,   # Index of the tag\n                    key0,   # Key of the tag\n                    val0    # Value of the tag\n                    )\n                self.indx += e_len\n                i = 0\n                while (i < e_len):\n                    output_items[0][i] = encoded[i]\n                    i += 1\n                return (e_len)\n\n        elif (self.state == 3):\n            # send file name\n            fn_len = len (self.FileName)\n            key1 = pmt.intern(\"packet_len\")\n            val1 = pmt.from_long(fn_len+8)\n            self.add_item_tag(0, # Write to output port 0\n                self.indx,   # Index of the tag\n                key1,   # Key of the tag\n                val1    # Value of the tag\n                )\n            self.indx += (fn_len+8)\n            i = 0\n            while (i < 8):\n                output_items[0][i] = self.filler[i]\n                i += 1\n            j = 0\n            while (i < (fn_len+8)):\n                output_items[0][i] = ord(self.FileName[j])\n                i += 1\n                j += 1\n            self.state = 4\n            return (fn_len+8)\n\n        elif (self.state == 4):\n            # send post filler\n            if (self._debug):\n                print (\"[EPB encode] state = 4\", self.pre_count)\n            key1 = pmt.intern(\"packet_len\")\n            val1 = pmt.from_long(self.f_len)\n            self.add_item_tag(0, # Write to output port 0\n                self.indx,   # Index of the tag\n                key1,   # Key of the tag\n                val1    # Value of the tag\n                )\n            self.indx += self.f_len\n            i = 0\n            while (i < self.f_len):\n                output_items[0][i] = self.filler[i]\n                i += 1\n            self.pre_count += 1\n            if (self.pre_count > 16):\n                self.pre_count = 0\n                self.state = 0      # idle\n            return (self.f_len)\n\n        return (0)\n\n"
    comment: |-
      Filename is specified on the command line, e.g.:
      python3 pkt_xmt.py --InFile="../gr-logo.png"

      The EPB block functions:
      1. Send a preamble (32bits "11100001010110101110100010010011") to allow the receiver to synchronize.
      2. Read the file in "Pkt_Len" chunks.
      3. Convert the data to Base64, which produces 4 bytes of output for every 3 bytes of input.
      4. Send each Base64 chunk with revised "packet_len" tags.
      5. Send a post-file filler to assure that any buffers have been flushed.
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\nimport base64\n\nclass blk(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name='EPB: Decode Packet',   # will show up in GRC\n            in_sig=None,\n            out_sig=None)\n        self.message_port_register_in(pmt.intern('msg_in'))\n        self.message_port_register_out(pmt.intern('msg_out'))\n        self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)\n\n    def handle_msg(self, msg):\n        _debug = 2\n          # set to zero to turn off diagnostics\n        try:\n            buff = pmt.to_python(pmt.cdr(msg))\n        except Exception as e:\n            gr.log.error(\"[EPB decode] Error with message conversion: %s\" % str(e))\n            return\n        b_len = len (buff)\n\n        if (buff[0] == 37):     # preamble or postamble\n            if ((buff[4] == 35) and (b_len < 52)):     # filename starts in buff[8]\n                print (\"End of text\")\n                if (_debug == 2):\n                    print (\"[EPB decode] buff =\", buff, b_len)\n                intlist = np.frombuffer(buff, dtype=np.uint8)\n                ofn = ''.join(chr(i) for i in intlist[8:])  \n                print (\"[EPB decode] Transmitted file name:\",ofn)\n\n        else:\n            # decode Base64\n            data = base64.b64decode(buff)\n            if (_debug == 1):\n                print (\"[EPB decode] data =\", data)\n            pdu = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(data),list(data)))\n            self.message_port_pub(pmt.intern('msg_out'), pdu)\n\n"
    comment: |-
      Strip preamble and postamble
      Convert Base64 to original file content
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: 0,2,1,2
    gui_hint: 0,2,1,2
    name: '"Rx Constellation"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    comment: 1,2,1,1
    gui_hint: 1,2,1,2
    name: '"Tx Constellation"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: usrp_rate
    comment: 0,0,1,2
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,2
    name: '"Rx Frequency"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: 2,0,1,2
    entags: 'False'
    gui_hint: 2,0,1,2
    label1: ''
    name: Transmit data
    size: '256'
    srate: usrp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,1,1,1
    gui_hint: 1,1,1,1
    label1: ''
    name: Rx Correlate Output
    size: '256'
    srate: usrp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,1
    gui_hint: 1,0,1,1
    label1: ''
    name: Rx Correlate input
    size: '256'
    srate: usrp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    dev_args: num_send_frames=128,send_frame_size=4096
    gain0: tx_gain
    samp_rate: usrp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    gain0: rx_gain
    samp_rate: usrp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: v1
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: v1
  states: {state: disabled}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_uchar_to_float_0_0_0_0, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', virtual_sink_1, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_uchar_to_float_0_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_1_0, '0']
- [digital_constellation_modulator_0, '0', uhd_usrp_sink_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_tag_debug_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_diff_decoder_bb_0, '0', virtual_sink_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_symbol_sync_xx_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_linear_equalizer_0, '0', virtual_sink_0, '0']
- [digital_map_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_map_bb_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_0, '0', digital_crc32_bb_0, '0']
- [epy_block_0_0, msg_out, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_0_0, msg_in]
- [uhd_usrp_source_0, '0', digital_fll_band_edge_cc_0, '0']
- [virtual_source_0, '0', digital_costas_loop_cc_0, '0']
- [virtual_source_0_0, '0', blocks_repack_bits_bb_0_0, '0']
- [virtual_source_0_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_1, '0', digital_crc32_bb_0, '0']
- [virtual_source_2, '0', digital_map_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
